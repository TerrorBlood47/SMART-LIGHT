# Keil uVision project uart.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uart
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c RccConfig.c RccConfig.h Delay.h Delay.c PWM.c PWM.h UART2.c UART2.h UART3.c UART3.h
software components: CMSIS:CORE 6.2.0, Device:Startup 2.6.3
